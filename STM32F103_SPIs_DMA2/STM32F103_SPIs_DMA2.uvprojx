# Keil uVision project STM32F103_SPIs_DMA2.uvprojx, settings and files
target STM32F103_SPIs_DMA2 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_SPIs_DMA2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\STM32F103_SPIs_DMA2;.\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h init_LED.h delay.h init_SPI.h
  group init
    ./init/: init_LED.c delay.c init_SPI.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
